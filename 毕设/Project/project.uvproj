# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group project
    ../file/: main.c
  group file
    ../file/: DHT11.c DHT11.h lcd.c lcd.h math.h public.c public.h usart.c usart.h
